# Keil uVision project STM32F103C8T6.uvprojx, settings and files
target stm32f103C8T6_mode (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8T6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\User;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\Pulser;..\HARDWARE\USART;..\HARDWARE\quantity;..\HARDWARE\12864;..\HARDWARE\keyboard
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Hardware
    ../HARDWARE/Pulser/: pulser.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/quantity/: quantity.c
    ../HARDWARE/12864/: 12864.c
    ../HARDWARE/keyboard/: key.c
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SysLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_adc.c
  group README
    ../: README.TXT
